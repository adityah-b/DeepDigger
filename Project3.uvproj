# Keil uVision project Project3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project3
  c flags: Optim=1
  c define: __RTGT_UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group Source Code
    ./: ece_spi.c MPU9250.c Retarget.c RTX_config.c sensor_fusion.c uart.c Multi_task.c led.c
  group System Code
    C:/Software/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
